## package/sbp_settings_client/Config.in
```kconfig
config BR2_PACKAGE_SBP_SETTINGS_CLIENT
	bool "sbp_settings_client"
	select BR2_PACKAGE_CZMQ
	select BR2_PACKAGE_LIBSBP
```
